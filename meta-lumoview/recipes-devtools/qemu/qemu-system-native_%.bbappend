PACKAGECONFIG:append = " \
    gtk+ \
"
